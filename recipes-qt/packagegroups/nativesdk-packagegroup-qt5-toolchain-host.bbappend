RDEPENDS_${PN} += " \
    nativesdk-qtquickcompiler \
"