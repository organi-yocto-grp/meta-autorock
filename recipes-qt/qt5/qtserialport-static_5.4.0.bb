require qt5-static-module-${PV}.inc
require qmake5-static-module.inc

QT_MODULE = "qtserialport"

LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=eb6c371255e1262c55ae9b652a90b528 \
                    file://LICENSE.FDL;md5=3801d7932fdc07fd9efe89f9854a6caa"

SRC_URI[md5sum] = "691b0b71e4ad791a37e288b41979662c"
SRC_URI[sha256sum] = "0fc619ef714f5b920ff19ec811b6459c849fafcc697ef4091dbb74e45bd058c3"

